# IAR project MM32F3277LLD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS; MM32; MM32\mLLD; MM32\Sfr; Peripheral; StartUp; MM32\mLLD\RCC; MM32\mLLD\GPIO; MM32\mLLD\UART; MM32\mLLD\_PinMap; MM32\mLLD\SPI; MM32\mLLD\SDIO; Peripheral\OLED; Peripheral\UART_Upload; Peripheral\P18; Isr; Peripheral\SWIIC; Peripheral\SWSDIO; Peripheral\SWSPI; MM32\mLLD\TIM; MM32\mLLD\TIM\PIT; Code\Menu; MM32\mLLD\EXTI; MM32\mLLD\FLASH; Peripheral\HOST; MM32\mLLD\DAC; MM32\mLLD\ADC
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MM32F3277LLD.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\MindMotion\MM32F3270.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h tz_context.h
  group Code/Menu
    Code/Menu/: menu.c menu.h menuTask.c menuTask.h
  group Isr
    Isr/: Isr.c Isr.h
  group MM32/mLLD
    MM32/mLLD/: common.c common.h
  group MM32/mLLD/ADC
    MM32/mLLD/ADC/: MM32_ADC.c MM32_ADC.h MM32_ADCDMA.c MM32_ADCDMA.h
  group MM32/mLLD/DAC
    MM32/mLLD/DAC/: MM32_DAC.c MM32_DAC.h
  group MM32/mLLD/EXTI
    MM32/mLLD/EXTI/: MM32_EXTI.c MM32_EXTI.h
  group MM32/mLLD/FLASH
    MM32/mLLD/FLASH/: MM32_FLASH.c MM32_FLASH.h
  group MM32/mLLD/GPIO
    MM32/mLLD/GPIO/: MM32_GPIO.c MM32_GPIO.h
  group MM32/mLLD/RCC
    MM32/mLLD/RCC/: MM32_RCC.c MM32_RCC.h
  group MM32/mLLD/SDIO
    MM32/mLLD/SDIO/: MM32_SDCard.c MM32_SDCard.h MM32_SDIO.c MM32_SDIO.h
  group MM32/mLLD/SPI
    MM32/mLLD/SPI/: MM32_SPI.c MM32_SPI.h MM32_SPIDMA.c MM32_SPIDMA.h
  group MM32/mLLD/TIM
    MM32/mLLD/TIM/: MM32_TIM.c MM32_TIM.h
  group MM32/mLLD/TIM/PIT
    MM32/mLLD/TIM/PIT/: MM32_PIT.c MM32_PIT.h
  group MM32/mLLD/UART
    MM32/mLLD/UART/: MM32_UART.c MM32_UART.h MM32_UARTDMA.c MM32_UARTDMA.h
  group MM32/Sfr
    MM32/Sfr/: MM32_ADCReg.h MM32_ADCRegDef.h MM32_COMPReg.h MM32_COMPRegDef.h MM32_CRCReg.h MM32_CRCRegDef.h MM32_CRSReg.h MM32_CRSRegDef.h MM32_DACReg.h MM32_DACRegDef.h MM32_DMAReg.h MM32_DMARegDef.h MM32_EXTIReg.h MM32_EXTIRegDef.h MM32_FLASHReg.h MM32_FLASHRegDef.h MM32_FSMCReg.h MM32_FSMCRegDef.h MM32_GPIOReg.h MM32_GPIORegDef.h MM32_I2CReg.h MM32_I2CRegDef.h MM32_IWDGReg.h MM32_IWDGRegDef.h MM32_PWRReg.h MM32_PWRRegDef.h MM32_RCCReg.h MM32_RCCRegDef.h MM32_RegBase.h MM32_RegTypedef.h MM32_RTC_BKPReg.h MM32_RTC_BKPRegDef.h MM32_SDIOReg.h MM32_SDIORegDef.h MM32_SPIReg.h MM32_SPIRegDef.h MM32_SYSCFGReg.h MM32_SYSCFGRegDef.h MM32_TIM_1_8_Reg.h MM32_TIM_1_8_RegDef.h MM32_TIM_2_5_Reg.h MM32_TIM_2_5_RegDef.h MM32_TIM_3_4_Reg.h MM32_TIM_3_4_RegDef.h MM32_TIM_6_7_Reg.h MM32_TIM_6_7_RegDef.h MM32_TIMReg.h MM32_TIMRegDef.h MM32_UARTReg.h MM32_UARTRegDef.h MM32_USBReg.h MM32_USBRegDef.h MM32_WWDGReg.h MM32_WWDGRegDef.h
  group Peripheral/HOST
    Peripheral/HOST/: HOST.c HOST.h
  group Peripheral/OLED
    Peripheral/OLED/: OLED.c OLED.h OLED_Font.c OLED_Font.h
  group Peripheral/P18
    Peripheral/P18/: P18_Analog.c P18_Analog.h P18_CMD.c P18_CMD.h P18_CTRL.c P18_CTRL.h P18_TYPEDEF.c P18_TYPEDEF.h P18_UART.c P18_UART.h
  group Peripheral/SWIIC
    Peripheral/SWIIC/: SWIIC.c SWIIC.h
  group Peripheral/SWSDIO
    Peripheral/SWSDIO/: SWSDIO.c SWSDIO.h
  group Peripheral/SWSPI
    Peripheral/SWSPI/: SWSPI.c SWSPI.h
  group Peripheral/UART_Upload
    Peripheral/UART_Upload/: UART_Upload.c UART_Upload.h
  group StartUp
    StartUp/: startUp.s startUp_.c startUp_.h
